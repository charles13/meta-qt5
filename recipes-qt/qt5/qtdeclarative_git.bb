require qt5-git.inc
require ${PN}.inc

SRCREV = "5870667929ac5f45805b1e1e656fec81b9b22337"
