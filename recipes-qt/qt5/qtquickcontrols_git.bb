require qt5-git.inc
require ${PN}.inc

SRCREV = "13aad0cf03170cde6dd147f9d2ce460bac98d712"
