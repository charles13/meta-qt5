require qt5-git.inc
require ${PN}.inc

SRCREV = "8d5f3bd730486b3fd3d5b1782fa70b80108c0ba4"
