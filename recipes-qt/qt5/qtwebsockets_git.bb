require qt5-git.inc
require ${PN}.inc

SRCREV = "0a9cbcf2894f4f9e621e0f5fb644d2b5e15ab2c7"
