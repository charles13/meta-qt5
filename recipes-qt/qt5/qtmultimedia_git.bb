require qt5-git.inc
require ${PN}.inc

SRCREV = "be0a231be4ed28474271fb29f44e1eb3270f35b7"
