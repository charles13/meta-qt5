require qt5-git.inc
require ${PN}.inc

SRCREV = "ccb40b720a675242b5b93333e5a56d5938086e0c"
