require qt5-git.inc
require ${PN}.inc

SRCREV = "cbd16183528d6e6127891801048dc16014d26ae5"
