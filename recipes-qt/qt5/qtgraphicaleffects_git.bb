require qt5-git.inc
require ${PN}.inc

SRCREV = "4ee79d3eb4baef9e5b2a3d263f002a24184d0e6e"
