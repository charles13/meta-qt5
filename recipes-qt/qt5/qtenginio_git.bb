require qt5-git.inc
require ${PN}.inc

QT_MODULE_BRANCH = "1.2"
SRCREV = "efac3cd245e2610924133e304d15bf726f5864f5"
