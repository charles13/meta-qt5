require qt5-git.inc
require ${PN}.inc

SRCREV = "1783179280dda6e470b0a429d4533db544b3c7b2"
