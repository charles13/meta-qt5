require qt5-git.inc
require ${PN}.inc

SRCREV = "03629b992766fe30ad148ccdf732e0aa1ec0171e"
