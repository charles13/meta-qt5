require qt5-git.inc
require ${PN}.inc

SRCREV = "0dc8719647eca19fd0828a86f5e61d21e0b774ad"
