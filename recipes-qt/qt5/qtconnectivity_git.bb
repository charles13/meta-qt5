require qt5-git.inc
require ${BPN}.inc

SRCREV = "8589703bd4e377eeb2a01c43f0c13542f54133ba"
