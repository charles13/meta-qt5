require qt5-git.inc
require ${PN}.inc

SRCREV = "5b1a3318125b72563b5de1bf7549088165ec60f4"
