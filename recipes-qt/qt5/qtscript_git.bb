require qt5-git.inc
require ${PN}.inc

SRCREV = "f8a48df4fcb2b40c2978c4e446bc6599c942aa32"
