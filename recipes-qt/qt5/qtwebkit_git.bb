require qt5-git.inc
require ${PN}.inc

SRCREV = "0f68b45974d9da98af22a5d33269bd31c8726221"
