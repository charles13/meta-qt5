require qt5-git.inc
require ${PN}.inc

SRCREV = "7e767afb429910adc0e9a219c5d600b55f6d72d1"
