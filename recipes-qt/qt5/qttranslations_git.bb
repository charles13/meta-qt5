require qt5-git.inc
require ${PN}.inc

SRCREV = "8eb8dcb1af39cd6129031becc52fa4d6222166e3"
