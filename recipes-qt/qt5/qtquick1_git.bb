require qt5-git.inc
require ${PN}.inc

SRCREV = "15daa5fe1c347b0cad80e46c1aafe1de728c3c06"
