require qt5-git.inc
require ${PN}.inc

SRCREV = "ec4c8d4a75a811d5440a297df0d7c6ebb7d56522"
